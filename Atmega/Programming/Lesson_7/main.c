#include <stdio.h>

int main()
{
  printf("\">\" =========================\r\n");
  int i=10, j;
  while(i > 5)
  {
    printf("i = %d\r\n", i);
    i--;
  }
  //------------------------
  printf("\">=\" =========================\r\n");
  for(i = 7; i >= 3; i--)	printf("i = %d\r\n", i);
  //------------------------
  printf("\"<\" =========================\r\n");
  i=0;
  while(i < 5)
  {
    printf("i = %d\r\n", i);
    i++;
  }
  //------------------------
  printf("\"<=\" =========================\r\n");
  i=0;
  do
  {
    printf("i = %d\r\n", i);
    i++;
  } while(i <= 5);
  //------------------------
  printf("\"==\" =========================\r\n");
  i=5;
  while(i == 5)
  {
    printf("i = %d\r\n", i);
    i++;
  }
  //------------------------
  printf("\"!=\" =========================\r\n");
  i=0;
  while(i != 5)
  {
    printf("i = %d\r\n", i);
    i++;
  }
  //------------------------
  printf("\"&&\" =========================\r\n");
  i = 0;
  j = 0;
  while((i <= 5) && (j <= 7))
  {
    printf("i = %d\r\n", i);
    i++;
    j++;
  }
  //------------------------
  printf("\"||\" =========================\r\n");
  i = 0;
  j = 0;
  while((i <= 5) || (j <= 7))
  {
    printf("i = %d\r\n", i);
    i++;
    j++;
  }
  //------------------------
  printf("\"!\" =========================\r\n");
  i=0;
  while(!(i > 5))
  {
    printf("i = %d\r\n", i);
    i++;
  }
  //------------------------
  printf("=========================\r\n");
  //------------------------
  return 0; //Return an integer from a function
}